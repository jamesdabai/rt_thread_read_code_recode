# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: SWM320xE Synwit SWM320xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\include; Libraries\CMSIS\DeviceSupport; Libraries\SWM320_StdPeriph_Driver; drivers; .; applications; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh; Libraries\CMSIS\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Libraries
    Libraries/CMSIS/DeviceSupport/: system_SWM320.c
    Libraries/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_can.c SWM320_crc.c SWM320_dma.c SWM320_exti.c SWM320_flash.c SWM320_gpio.c SWM320_i2c.c SWM320_lcd.c SWM320_norflash.c SWM320_port.c SWM320_pwm.c SWM320_rtc.c SWM320_sdio.c SWM320_sdram.c SWM320_spi.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c
    Libraries/CMSIS/DeviceSupport/startup/iar/: startup_SWM320.s
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
