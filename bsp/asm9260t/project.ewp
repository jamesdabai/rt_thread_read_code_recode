# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9260 Atmel AT91SAM9260
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC
  ICCARM.CCIncludePath2: ../../libcpu/arm/common; ../../components/drivers/include; platform; ../../components/libc/compilers/dlib; drivers; ../../libcpu/arm/arm926; .; applications; ../../include; ../../components/finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: platform
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: D:\GitHub\rt-thread\bsp\asm9260t\link_scripts\sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; RT_USING_DLIBC
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Applications
    applications/: application.c
  group ARM926
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/arm926/: context_iar.S cpuport.c mmu.c stack.c start_iar.S trap.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    drivers/: board.c led.c usart.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group platform
    platform/: gpio.c interrupt.c reset.c rt_low_level_init.c system_clock.c timer0.c uart.c
